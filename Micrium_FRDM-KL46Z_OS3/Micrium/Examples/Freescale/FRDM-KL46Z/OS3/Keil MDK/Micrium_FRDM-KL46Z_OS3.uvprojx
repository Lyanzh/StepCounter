# Keil uVision project Micrium_FRDM-KL46Z_OS3.uvprojx, settings and files
target Micrium_FRDM-KL46Z_OS3 (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Micrium_FRDM-KL46Z_OS3 +hex
  c flags: Optim=1
  c include: ..\;..\..\BSP;..\..\BSP\KeilMDK;..\..\BSP\OS\uCOS-III;..\..\BSP\Freescale;..\..\..\..\..\Software\uC-CPU;..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M0\RealView;..\..\..\..\..\Software\uC-LIB;..\..\..\..\..\Software\uC-LIB\Ports\ARM-Cortex-M0\Generic\RealView;..\..\..\..\..\Software\uCOS-III\Source;..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M0\Generic\RealView
  asm misc: --cpreproc
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group APP
    ../: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c cpu_bsp.c bsp_lcd.c bsp_lcd.h bsp_i2c.c bsp_i2c.h bsp_uart.c bsp_uart.h bsp_mma8451q.c bsp_mma8451q.h
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
    ../../BSP/Freescale/: MKL46Z4.h
    ../../BSP/KeilMDK/: cstartup.s
  group uC-LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS-III
    ../../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC-CPU
    ../../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../../Software/uC-CPU/ARM-Cortex-M0/RealView/: cpu.h cpu_a.asm cpu_c.c
