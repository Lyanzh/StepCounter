<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Micrium_FRDM-KL46Z_OS3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


